<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\WeatherPanel.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\WeatherPanel_PKS5D9\WeatherPanel.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\WeatherPanel_PEHMI1\WeatherPanel.ewp</path>
    </project>
    <batchBuild />
</workspace>
